## boards/shields/trk_numpad/Kconfig.defconfig
```kconfig
if SHIELD_TRK_NUMPAD

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "trk-numpad"

endif
```
